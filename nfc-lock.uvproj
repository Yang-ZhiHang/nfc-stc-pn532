# Keil uVision project nfc-lock.uvproj, settings and files
target nfc-lock-project (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: nfc-lock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include;.\include\drivers;.\include\utils
  group Source
    ./src/: main.c
  group drivers
    ./src/drivers/: buzzer.c led.c nfc.c servo.c uart.c
  group utils
    ./src/utils/: delay.c
